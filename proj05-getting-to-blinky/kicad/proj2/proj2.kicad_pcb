# Repository tonygilkerson/things

File README.md:

# Things

This repo is intended to hold the notes and code examples that I work through as I am learning how to program microcontrollers.

## Why?

My current goal is to learn how to program microcontrollers such as the [Pico](https://www.raspberrypi.com/products/raspberry-pi-pico/) or [ESP32](https://en.wikipedia.org/wiki/ESP32). I have several automation projects in mind, mostly involved with watering, climate control and tracking.  I also have a few project ideas for my computerized telescope to automate long imaging sessions. A secondary goal is to use a "real" programming language like Go for may projects.  I have looked at the Arduino IDE, which seems to be very popular, but I am not really interested.  Same for the visual programming tools that I have seen.

## What?

This repo has several subfolders each containing the source code and doc for some project. The first subfolder `proj01` is me working through a "hello world" project, which for a microcontrollers is a blinking LED. The code is not that interesting but my notes will be from the point of view of a newbie and thus may contain things that were useful to me at the the time.

## Reference

* [Component Reference](component-ref.md)
* [Microcontroller Reference](microcontroller-ref.md)

## Ideas for future projects

* [TryBotics](https://trybotics.com/project/tinygo-on-arduino-uno-an-introduction-6130f6) - has a good list of prjects
* [Astro Tracker](https://learn.adafruit.com/diy-robotic-sky-tracking-astrophotography-mount) - a DIY Robotic Sky Tracking Astrophotography Mount

## KiCad design proj05-getting-to-blinky/kicad/proj2/proj2.kicad_pcb

File proj05-getting-to-blinky/README.md:

# Getting To Blinky

This section is for the project files as I work through this. tutorial

> https://contextualelectronics.com/courses/getting-to-blinky-5-0/

Note: I created `kicad/proj` following along with the *gitting to blinky* tutorial but did not realize until late that it was for surface mount components.  `kicad/proj2` is my attempt to redo the same tutorial but with Through Hole Technology Mounting (THT) components.

* `kicad/proj` - SMT
* `kicad/proj2` - THT

## Ref

* https://octopart.com/
* https://oshpark.com/

Parts:
BT1: CR3022; Coin_Cell_Battery_Holder_3V_PN_107_THT
C1: 1u; C_Radial_D5.0mm_H11.0mm_P2.00mm
D1: LED; LED_D4.0mm
H1, H2, H3: MountingHole; MountingHole_3mm
R1: 1k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R2: 100k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R3: 470; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
U1: NTE955MC; DIP-8_W7.62mm

Connections:
GND: BT1.2 (-), C1.2, D1.1 (K), U1.1 (GND)
unnamed: BT1.1 (+), R1.1, U1.4 (Reset), U1.8 (Vcc)
unnamed: C1.1, R2.2, U1.2 (Trigger), U1.6 (Thres)
unnamed: D1.2 (A), R3.2
unnamed: R1.2, R2.1, U1.7 (Disch)
unnamed: R3.1, U1.3 (Output)

Notes on the sheet:
Mounting Holes

Board: 2 copper layers, 36.3 x 47.6 mm, 10 parts (0 on the bottom side), 6 nets.

## Commit log

2022-04-12 add example 1
2022-04-16 youtube prez
2022-04-18 add more resource links
2022-04-20 start of project 2
2022-04-21 add youtube video link
2022-04-21 add stepper example
2022-04-25 proj04 is working mostly
2022-04-25 m5 stack LEDs
2022-04-25 got G25/G36 working on M5
2022-04-26 start proj05
2022-04-27 i dont know
2022-04-27 mods
2022-04-28 proj02 video
2022-04-28 typo
2022-04-29 add pics
2022-04-29 add images
2022-04-29 stepper wiring
2022-04-29 proj05 setup drawing
2022-05-02 make stepper proj3
2022-05-04 finish up proj03
2022-05-05 tweek proj03
2022-05-07 no need to configure pin on proj03
2022-05-08 small workding changes
2022-05-15 make step rpm float32
2022-05-18 proj97 work in progress
2022-05-21 got steps for one ota rotation
2022-05-21 dont checkin .vscode subdir
2022-05-22 allow position to be negative
2022-05-23 set stepDelay directly
2022-05-27 start proj04
2022-05-27 add component ref
2022-05-29 cleanup doc proj04
2022-06-02 got OLED to work
2022-06-08 starting new project after proj04
2022-06-11 add kicad to proj99
2022-06-11 add power module
2022-06-11 add getting to blinky tutoral
2022-06-13 getting to blinky in progress
2022-06-14 pcb done
2022-06-15 blinky proj
2022-06-18 add footprints to proj05
2022-06-19 pcb layout proj05
2022-06-20 add artwork to proj5
2022-06-20 add mounting holes proj5
2022-06-22 reduce image size
2022-06-22 STEPPERONLINE 0.9deg Nema 17 Stepper Motor
2022-06-23 reorg a few thing
2022-06-24 organize project folders
2022-06-24 more reorgs
2022-06-24 combine astrostepper and oled
2022-06-25 move component catlog to its own page
2022-06-25 kicad start proj07
2022-06-26 proj07 stepper is working
2022-06-26 remove backups
2022-06-26 proj07 stepper and oled display are working, not time to write some code
2022-06-27 add astroDisplay package
2022-06-27 proj07 progressing well
2022-06-28 update proj07 readme
2022-06-28 Project images
2022-06-28 add project pics for proj07
2022-06-28 Proj pic
2022-07-03 add pico1
2022-07-03 add kicad to proj08
2022-07-04 add astrostepper in proj08
2022-07-05 more on raDriver in proj08
2022-07-05 proj08 more on raDriver
2022-07-06 add run to driver in proj08
2022-07-06 more go channel testing
2022-07-07 hacked version of to go routines working kind of
2022-07-10 pwm and ole display good start proj09
2022-07-14 fix ratio
2022-07-16 reorg some components
2022-07-18 add astroeq driver
2022-07-19 proj09 astroeq in progress
2022-07-24 document pins wiring in proj09
2022-07-26 amt productid
2022-07-28 add amt cables
2022-08-03 add to components amt22 info
2022-08-04 add interface to display
2022-08-06 working get position for encoder
2022-08-15 add encode pairty check
2022-08-18 got uart working?
2022-08-23 got uart working in proj09
2022-08-28 encoder and display working proj09
2022-09-01 oled and encoder looking good for proj09
2022-09-05 initial start on HID
2022-09-13 debounce button success
2022-09-16 number key buttons wired up proj10
2022-09-17 all keys wired up proj10
2022-09-19 debounce in interrupt
2022-10-16 got LCD proj11 working
2022-10-21 pub sub progressing
2022-10-25 msg pub/sub working
2022-10-28 got pub working
2022-10-30 add generic
2022-11-01 make message constants
2022-11-05 proj10 OLED working
2022-11-10 hid update
2023-01-23 test
2023-02-17 lora-e5-dev-kit
2023-02-18 ST-LINK v4 wireup
2023-02-19 hello world works
2023-02-19 update doc
2023-03-12 ToF with display
2023-03-19 add fsm project
2023-03-19 fsm with context
2023-03-20 fsm with test
2023-03-25 add magnetometer
2023-04-02 add proj20-pir
2023-04-15 add lora-e5 mini
2023-04-17 more doc
2023-05-19 add min proj
2023-05-25 add mic proj
2023-06-04 checkpoint
2023-06-14 simple trans
2023-07-03 neopixl
2023-07-11 neo learn
2023-07-13 epaper works
2023-07-13 epaper hello world
2023-07-14 do fonts
2023-09-07 restore epaber to spi0
2023-09-24 add btn
2023-09-25 gosched example
2023-09-29 check point
2024-02-22 add moisture sensor
2024-02-23 improve proj33
2024-02-23 add temperature
2024-02-25 add Soil Sensor
2024-02-27 change soil pins
2024-03-01 add hack for tm1637
2024-03-05 add m4 4-relay
2024-03-06 add sprinkler
2024-03-14 add l293d
2024-03-14 add l293d hbridge project
2024-03-26 add viration-sensor
2024-04-01 add tone project
2024-07-04 add pico w
